# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "D:\ti\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__,MPU6050,MOTION_DRIVER_TARGET_MSPM0
  c include: ../;D:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;D:\ti\mspm0_sdk_2_10_00_04\source;..\encoder;..\interrupt;..\OLED;..\serial;..\motor;..\tcs34725;..\MPU6050;..\PID
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\ti\mspm0_sdk_2_10_00_04/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group interrupt
    ../interrupt/: interrupt.c interrupt.h clock.c clock.h
  group OLED
    ../OLED/: IOI2C.c IOI2C.h OLED.c OLED.h oledfont.h
  group serial
    ../serial/: serial.c serial.h
  group motor
    ../motor/: motor.h motor.c
  group MPU6050
    ../MPU6050/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h mspm0_i2c.c mspm0_i2c.h
  group encoder
    ../encoder/: encoder.c encoder.h
  group PID
    ../PID/: pid.c pid.h
